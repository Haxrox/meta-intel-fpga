LINUX_VERSION = "5.15.90"
LINUX_VERSION_SUFFIX = "-lts"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "5d086f5ff504662ee8a49b0165a38a18ed6dfb18"

include linux-socfpga.inc
