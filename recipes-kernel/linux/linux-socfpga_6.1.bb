LINUX_VERSION = "6.1"

SRCREV = "5786aaff93079c1ca03a54cd2d53b54784c4e8f5"

include linux-socfpga.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
