require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.9.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "5c59b622cdc80af2472ee00e288c6afade19a035"
