require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.7.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "b179839aebb787a8ae3196345d7739e47d3069f0"
