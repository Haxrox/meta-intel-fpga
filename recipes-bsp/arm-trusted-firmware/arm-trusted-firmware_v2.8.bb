require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.8.0"
ATF_BRANCH = "socfpga_agilex5-23.1_RC"

SRCREV = "bf3935bd04294520327ee24dbb0749f9ffad8322"
