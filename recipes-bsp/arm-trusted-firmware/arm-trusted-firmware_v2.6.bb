require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.6.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "cb156a535cc85467d64fc9f5efff937497991256"
