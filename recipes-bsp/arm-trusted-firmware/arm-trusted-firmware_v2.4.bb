require arm-trusted-firmware.inc

ATF_VERSION = "v2.4.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "b56764673f0935c6288ea5a711fa193177f6d6ec"
