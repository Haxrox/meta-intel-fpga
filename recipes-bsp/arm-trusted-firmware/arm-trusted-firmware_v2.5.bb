require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=713afe122abbe07f067f939ca3c480c5"

ATF_VERSION = "v2.5.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "22e72eb508c4e293ae54439ba678b72f592a42a6"
