require arm-trusted-firmware.inc

SRCREV = "b883cb8f21862cf7a1b2097e749533b3335944e0"
