require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2023.04"

SRCREV = "ae0fa7362f263cbddd37d36e0463a5c99bba2c77"
