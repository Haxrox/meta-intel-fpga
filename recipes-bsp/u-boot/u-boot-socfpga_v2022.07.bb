require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2022.07"

SRCREV = "566c7991a6b24fa88476b0668d9f7e62f9ce5439"
