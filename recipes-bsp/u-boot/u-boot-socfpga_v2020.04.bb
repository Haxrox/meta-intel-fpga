require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2020.04"

SRCREV = "66b56bb5bf4caaf29c75dfa8390c38a0c463a337"
