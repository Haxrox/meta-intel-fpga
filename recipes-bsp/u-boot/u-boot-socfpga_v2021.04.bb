require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "v2021.04"

SRCREV = "f7e401dabcd81538fc847f29d6c4c8871b59c1f2"
