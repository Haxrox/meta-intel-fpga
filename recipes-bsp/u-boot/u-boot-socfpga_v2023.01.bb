require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2023.10"

SRCREV = "35c6f437c45cd21ddf0f785b3bbd585bf066f053"
