require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2020.07"

SRCREV = "694f92d62ed594170726214d5a5a26f0cf3466a3"
